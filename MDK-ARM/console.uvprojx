# Keil uVision project console.uvprojx, settings and files
target console (5060960::V5.06 update 7 (build 960)::.\ARMcc)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: console +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../App/sys;../Components/scheduler;../Bsp/key;../Components/ebtn;../Bsp/ebtn;..\Bsp\uart;..\Test;..\Components\ringbuffer;..\Components\event_queue
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Components/Scheduler
    ../Components/scheduler/: scheduler.c scheduler.h
  group Componets/Ebtn
    ../Components/ebtn/: bit_array.h ebtn.c ebtn.h
  group Components/Ringbuffer
    ../Components/ringbuffer/: ringbuffer.c ringbuffer.h
  group Components/Event_queue
    ../Components/event_queue/: event_queue.c event_queue.h
  group Bsp/Key
    ../Bsp/key/: key_driver.c key_driver.h ebtn_driver.c ebtn_driver.h
  group Bsp/Uart
    ../Bsp/uart/: uart_driver.c uart_driver.h
  group Test
    ../Test/: sys_key_monitor.c sys_key_monitor.h
  group App/sys
    ../App/sys/: mydefine.h system_assembly.c system_assembly.h
software components: CMSIS:CORE 4.3.0
